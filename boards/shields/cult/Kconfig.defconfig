## boards/shields/cult/Kconfig.defconfig
```kconfig
if SHIELD_CULT

config ZMK_KEYBOARD_NAME
    default "cult"

config ZMK_RGB_UNDERGLOW
    default y

endif
```
